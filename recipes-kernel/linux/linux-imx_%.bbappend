# Customer Linux Patches
FILESEXTRAPATHS_prepend:= "${THISDIR}/files:"
include linux-imx.inc
